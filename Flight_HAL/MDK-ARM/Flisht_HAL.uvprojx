# Keil uVision project Flisht_HAL.uvprojx, settings and files
target Flisht_HAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Flisht_HAL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Midware/FreeRTOS;../Midware/FreeRTOS/include;../Midware/FreeRTOS/portable/RVDS/ARM_CM3;../App;../Common;../Int;../Int/MPU6050;..\Int\NRF24L01
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Mid/FreeRTOS
    ../Midware/FreeRTOS/: FreeRTOSConfig.h
  group Mid/FreeRTOS/source
    ../Midware/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Mid/FreeRTOS/portable
    ../Midware/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../Midware/FreeRTOS/portable/MemMang/: heap_4.c
  group Int
    ../Int/: Int_LED.c
    ../Int/MPU6050/: Int_MPU6050.c
    ../Int/NRF24L01/: NRF24L01.c
  group App
    ../App/: App_Flight.c App_Task.c
  group Common
    ../Common/: Com_IMU.c Com_Kalman.c Com_PID.c
software components: CMSIS:CORE 4.3.0
